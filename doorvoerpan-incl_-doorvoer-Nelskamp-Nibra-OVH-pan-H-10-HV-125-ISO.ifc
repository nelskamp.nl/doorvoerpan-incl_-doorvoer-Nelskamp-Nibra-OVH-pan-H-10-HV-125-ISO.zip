Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: aa54eced-3fe0-4c08-a1c5-ae584a38d6b0.ifc
Time: 2025-01-21T09:05:14
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcFlowTerminal, doorvoerpan incl. doorvoer Nelskamp - Nibra OVH pan H-10 HV 125 ISO
In: Bouwlaag
Material: terracotta
Pset_Data - WUID: AgAAAKZZqRwEAAAAhq4BAAVc6AAAj6cAADxtAQAyogEA5HIAAAIAAQUBAQAAAAEAAACDAAEBAAAAAgAAAHmBAAAFVpAAAIZSAACp5AAAXpMAAFSbAAAAAHYUAQAFZgQAAHbbAAA8bQEAEIgAAJquAAABABAAAQEAAAADAAAAuTwAAAX2tgAAZDAAAManAACjrQAA6dgAAAAA; Hyperlink: https://bcb-online.nl/?WUID=AgAAAKZZqRwEAAAAhq4BAAVc6AAAj6cAADxtAQAyogEA5HIAAAIAAQUBAQAAAAEAAACDAAEBAAAAAgAAAHmBAAAFVpAAAIZSAACp5AAAXpMAAFSbAAAAAHYUAQAFZgQAAHbbAAA8bQEAEIgAAJquAAABABAAAQEAAAADAAAAuTwAAAX2tgAAZDAAAManAACjrQAA6dgAAAAA; merk: Nelskamp; type: HV 125 ISO; kenmerkende grondstof: terracotta; serie: Nibra OVH pan H-10; tussenpan: keramische tussenpan Nelskamp - Nibra OVH pan H-10 normale zijsluiting natuurrood (201); doorvoerelement: dakpandoorvoer HV 125 ISO Nelskamp - HV 125 ISO
